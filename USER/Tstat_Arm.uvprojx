# Keil uVision project Tstat_Arm.uvprojx, settings and files
target STM32F103 (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32F103VC STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.2.0
  cpu: IROM(0x08000000,0x40000) IRAM(0x20000000,0xC000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: Tstat8_Rev6_2 +hex
  c flags: Optim=2 v6Lang=1 v6LangP=1
  c define: STM32F10X_HD, USE_STDPERIPH_DRIVER, TSTAT_ARM  TSTAT8_CODE
  c include: ..\CORE;..\USER;..\STM32F10x_FWLib\inc;..\HARDWARE\LED;..\HARDWARE\LCD;..\FreeRTOS\include;..\FreeRTOS\portable\RVDS\ARM_CM3;..\SYSTEM\delay;..\SYSTEM\usart;..\SYSTEM;..\HARDWARE\KEY;..\HARDWARE\IIC;..\HARDWARE\24CXX;..\HARDWARE\SPI;..\HARDWARE\TOUCH;..\HARDWARE\FLASH;..\HARDWARE\STMFLASH;..\HARDWARE\DMA;..\HARDWARE\SDCARD;..\FATFS\src;..\FATFS\exfuns;..\VMALLOC;..\HARDWARE\TIMER;..\HARDWARE\ENC28J60;..\uIP-1.0\uip;..\uIP-1.0\apps\dhcpc;..\uIP-1.0\apps\resolv;..\uIP-1.0\apps\webserver;..\uIP-APP;..\HARDWARE\RTC;..\USB\CONFIG\inc;..\USB\LIB\inc;..\USB\APP;..\MODBUS;..\TCPIP;..\BACNET\handler;..\BACNET\src;..\BACNET\include;..\BACNET;..\BACNET\object;..\EEP-MAP;..\HARDWARE\GPIO;..\HARDWARE\OUTPUT;..\USER;..\HARDWARE\INPUT
  memory RVCT4: ROM 0x8008000 size 0x38000
  memory RVCT9: RAM 0x20000000 size 0xc000
  group USER
    ./: main.c stm32f10x_it.c system_stm32f10x.c FreeRTOSConfig.h TstatFunctions.c control_logic.c hexinfo.c tstat7_menu.c max_dual_heat.c Constcode.c setpointlib_arm.LIB pidlib_arm.lib
    ../HARDWARE/STMFLASH/: stmflash.c
  group FWLIB
    ../STM32F10x_FWLib/src/: misc.c stm32f10x_adc.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_gpio.c stm32f10x_iwdg.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c stm32f10x_bkp.c stm32f10x_pwr.c
  group CMSIS
    ../CORE/: cortexm3_macro_rvds.s core_cm3.c startup_stm32f10x_hd.s
  group HARDWARE
    ../HARDWARE/LED/: led.c
    ../HARDWARE/KEY/: key.c
    ../HARDWARE/IIC/: myiic.c
    ../HARDWARE/24CXX/: 24cxx.c
    ../HARDWARE/SPI/: spi.c
    ../HARDWARE/TIMER/: timerx.c
    ../HARDWARE/RTC/: rtc.c
    ../HARDWARE/GPIO/: gpio_define.c
    ../HARDWARE/LCD/: tstat7_lcd.c ER-TFT024-3_4-Wire_SPI.c
    ../HARDWARE/INPUT/: inputs.c
    ../HARDWARE/OUTPUT/: output.c
  group FREERTOS
    ../FreeRTOS/: tasks.c list.c queue.c
    ../FreeRTOS/portable/RVDS/ARM_CM3/: port.c
    ../FreeRTOS/portable/MemMang/: heap_2.c
  group SYSTEM
    ../SYSTEM/usart/: usart.c
    ../SYSTEM/delay/: delay.c
  group MODBUS
    ../MODBUS/: modbus.c crc.c
  group FILTER
    ../FILTER/: filter.c
  group EEP-MAP
    ../EEP-MAP/: eep_mapping.c
  group bacnet
    ../bacnet/: bacnet_function.c store.c bacnet_ARM_rev10.lib
